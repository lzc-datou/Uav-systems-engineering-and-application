# Keil uVision project Rotor_Balance.uvprojx, settings and files
target Rotor_Balance (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Rotor_Balance +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\MPU6050_IIC_Hardware;..\HARDWARE\Motor;.\Control;..\HARDWARE\HMI;..\HARDWARE\USART1_DMA;..\HARDWARE\Timer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./Control/: control.c filter.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/MPU6050_IIC_Hardware/: mpu6050.c IMU.c
    ../HARDWARE/HMI/: hmi.c
    ../HARDWARE/USART1_DMA/: usart1.c usart2.c
    ../HARDWARE/Timer/: tim2.c tim4_int.c
software components: CMSIS:CORE 4.3.0
